options:
  parameters:
    author: niv karasenty and rephael riahi
    description: the audio transmition
    generate_options: qt_gui
    id: transmition_scheme
    output_language: python
    title: Transmition scheme
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 1e6
    stop: 3e9
    value: 2.4e9
  states: {}
- name: freq_diff
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: input_string
  id: variable
  parameters:
    value: '''AAAAAAA'''
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1e-2'
  states: {}
- name: timeout
  id: variable
  parameters:
    value: '8'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*np.pi*freq_diff/samp_rate
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: modulator_demodulate_0
  id: modulator_demodulate
  parameters:
    samp_rate: samp_rate
    t: t
    threshold: threshold
    timeout: timeout
  states: {}
- name: modulator_modulator_0
  id: modulator_modulator
  parameters:
    input_str: input_string
    samp_rate: samp_rate
    t: t
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_throttle2_0_0, '0']
- [analog_frequency_modulator_fc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_throttle2_0_0, '0', modulator_demodulate_0, '0']
- [modulator_modulator_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
