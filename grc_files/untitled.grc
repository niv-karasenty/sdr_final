options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: input_string
  id: variable
  parameters:
    value: '''hello evereyone this is our try to get a message'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: modulator_demodulate_0
  id: modulator_demodulate
  parameters:
    samp_rate: samp_rate
    t: t
    threshold: '1e-3'
    timeout: '10'
  states: {}
- name: modulator_modulator_0
  id: modulator_modulator
  parameters:
    input_str: input_string
    samp_rate: samp_rate
    t: t
  states: {}

connections:
- [blocks_throttle2_0, '0', modulator_demodulate_0, '0']
- [modulator_modulator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
