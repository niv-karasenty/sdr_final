options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: input_string
  id: variable
  parameters:
    value: '''AAAAAAAA'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_file
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: modulator_demodulate_0
  id: modulator_demodulate
  parameters:
    samp_rate: samp_rate
    t: t
    threshold: '0'
    timeout: '0'
  states: {}
- name: modulator_modulator_0
  id: modulator_modulator
  parameters:
    input_str: input_string
    samp_rate: samp_rate
    t: t
  states: {}

connections:
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', modulator_demodulate_0, '0']
- [modulator_modulator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
