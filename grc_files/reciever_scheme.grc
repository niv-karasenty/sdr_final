options:
  parameters:
    author: niv karasenty and rephael riahi
    description: reciever scheme
    generate_options: qt_gui
    id: reciever_scheme
    output_language: python
    title: reciever scheme
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.005'
  states: {}
- name: timeout
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: modulator_demodulate_0
  id: modulator_demodulate
  parameters:
    samp_rate: samp_rate
    t: t
    threshold: threshold
    timeout: timeout
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', modulator_demodulate_0, '0']
- [uhd_usrp_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
