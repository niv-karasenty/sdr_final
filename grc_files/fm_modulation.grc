options:
  parameters:
    author: nivkarasenty and rephaelriahi
    description: Trying to use fm modulation on our modulation to move it through sound
    generate_options: qt_gui
    id: fm_modulation
    output_language: python
    title: FM modulated signal
  states: {}

blocks:
- name: f_delta
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: input_str
  id: variable
  parameters:
    value: '''this is the signal we try to modulate'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1e-5'
  states: {}
- name: timeout
  id: variable_qtgui_range
  parameters:
    label: after how many unidentified bits shell I stop searching?
    start: '1'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: f_delta
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*np.pi*f_delta/samp_rate
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: modulator_demodulate_0
  id: modulator_demodulate
  parameters:
    samp_rate: samp_rate
    t: t
    threshold: threshold
    timeout: timeout
  states: {}
- name: modulator_modulator_0
  id: modulator_modulator
  parameters:
    input_str: input_str
    samp_rate: samp_rate
    t: t
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"time sink with all modulation"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"time sink before fm modulation"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"time domain after demodulating fm"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', modulator_demodulate_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_2, '0']
- [analog_frequency_modulator_fc_0, '0', analog_fm_demod_cf_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1, '0']
- [modulator_modulator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
