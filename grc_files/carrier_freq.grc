options:
  parameters:
    author: nivkarasenty
    generate_options: qt_gui
    id: carrier_freq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carry_freq
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: input_string
  id: variable
  parameters:
    value: '''AAA'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: timeout
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carry_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carry_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: modulator_demodulate_0
  id: modulator_demodulate
  parameters:
    samp_rate: samp_rate
    t: t
    threshold: threshold
    timeout: timeout
  states: {}
- name: modulator_modulator_0
  id: modulator_modulator
  parameters:
    input_str: input_string
    samp_rate: samp_rate
    t: t
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', modulator_demodulate_0, '0']
- [blocks_multiply_xx_1, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_1, '0']
- [modulator_modulator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
