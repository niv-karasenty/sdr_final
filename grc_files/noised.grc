options:
  parameters:
    author: nivkarasenty
    generate_options: qt_gui
    id: noised
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNR_dB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: SNR_lin
  id: variable
  parameters:
    value: np.pow(10,(SNR_dB/10))
  states: {}
- name: f_delta
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: input_str
  id: variable
  parameters:
    value: '''AAAA'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: t
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.15'
  states: {}
- name: timeout
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: f_delta
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*np.pi*f_delta/samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 1/(SNR_lin*samp_rate)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: modulator_demodulate_0
  id: modulator_demodulate
  parameters:
    samp_rate: int(samp_rate)
    t: t
    threshold: threshold
    timeout: timeout
  states: {}
- name: modulator_modulator_0
  id: modulator_modulator
  parameters:
    input_str: input_str
    samp_rate: int(samp_rate)
    t: t
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"time sink with all modulation"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"time sink before fm modulation"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"time domain after demodulating fm"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', modulator_demodulate_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_2, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_0, '1']
- [analog_frequency_modulator_fc_0, '0', qtgui_time_sink_x_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_throttle2_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1, '0']
- [modulator_modulator_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
